Commit message: Added box004-box007 urdf

File: PyBulletSim/box004.urdf (robot description, URDF)
Before this commit: robot box1, 1 links, 0 joints
Links:
- removed link box1_body
- added link box4_body, mass 0.297; collision box size=0.192 0.085 0.108; visual box size=0.192 0.085 0.108
